# IAR project sen_tran.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: AUTOSTART_ENABLE; PROJECT_CONF_H
  ICC8051.CCDiagSuppress: Pa050,Pa082,Pe550
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.PreInclude: ..\..\..\cpu\cc253x\cc253x.h
  ICC8051.CCIncludePath2: ..\..\..\cpu\cc253x; ..\..\..\platform\wsn2530dk; ..\..\..\core; ..\..\..\apps; $PROJ_DIR$
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: CC2530F256b.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
configuration coord (8051, debug)
  as the first configuration, except:
configuration sensor (8051, debug)
  as the first configuration, except:
  group core
    ../../../core/: contiki-lib.h contiki-net.h contiki-version.h contiki.h
  group core/dev
    ../../../core/dev/: battery-sensor.h eeprom.h leds.c leds.h radio-sensor.h radio.h rom.h serial-line.c serial-line.h slip.c slip.h spi.h watchdog.h xmem.h
  group core/lib
    ../../../core/lib/: checkpoint.c checkpoint.h list.c list.h memb.c memb.h print-stats.c print-stats.h ringbuf.c ringbuf.h sensors.c sensors.h
  group core/net
    ../../../core/net/: nbr-table.c nbr-table.h netstack.c netstack.h packetbuf.c packetbuf.h packetqueue.c packetqueue.h psock.c psock.h queuebuf.c queuebuf.h rime.h sicslowpan.c sicslowpan.h simple-udp.c simple-udp.h slipdev.c slipdev.h tcpdump.c tcpdump.h tcpip.c tcpip.h uip-debug.h uip-ds6-nbr.c uip-ds6-nbr.h uip-ds6-route.c uip-ds6-route.h uip-ds6.c uip-ds6.h uip-icmp6.c uip-icmp6.h uip-nd6.c uip-nd6.h uip-neighbor.c uip-neighbor.h uip-packetqueue.c uip-packetqueue.h uip-split.c uip-split.h uip-udp-packet.c uip-udp-packet.h uip.h uip6.c uip_arch.h uiplib.c uiplib.h uipopt.h
    ../../../core/net/rime/: rimeaddr.c rimeaddr.h rimestats.c rimestats.h
  group core/net/mac
    ../../../core/net/mac/: contikimac.c contikimac.h csma.c csma.h frame802154.c frame802154.h framer-802154.c framer-802154.h framer.h mac.c mac.h nullrdc.c nullrdc.h phase.c phase.h rdc.h
  group core/net/rpl
    ../../../core/net/rpl/: rpl-conf.h rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-of0.c rpl-private.h rpl-timers.c rpl.c rpl.h
  group core/sys
    ../../../core/sys/: autostart.c autostart.h cc.h clock.h ctimer.c ctimer.h dsc.h energest.c energest.h etimer.c etimer.h lc-switch.h loader.h log.h mt.c mt.h process.c process.h procinit.c procinit.h pt-sem.h pt.h rtimer.c rtimer.h stimer.c stimer.h subprocess.h timer.c timer.h
  group cpu
    ../../../cpu/cc253x/: 8051def.h cc253x.h compiler.h mtarch.h rtimer-arch.c rtimer-arch.h sfr-bits.h soc.c soc.h stack.c stack.h stdint.h
  group cpu/dev
    ../../../cpu/cc253x/dev/: cc2530-rf.c cc2530-rf.h clock-isr.h clock.c dma.c dma.h dma_intr.c lpm.h port.h port2-intr.c port2.c port2.h random.c uart-intr.c uart-intr.h uart.h uart0.c uart0.h uart1.c uart1.h watchdog.c
  group platform
    ./: CC2530F256b.xcl main-coord.c main-sensor.c
    ../../../platform/wsn2530dk/: contiki-conf.h contiki-main.c debug.c debug.h models.h putchar.c uip-debug.c viztool.c
  group platform/dev
    ../../../platform/wsn2530dk/dev/: adc-sensor.c adc-sensor.h button-sensor.c button-sensor.h io-arch.h leds-arch.c leds-arch.h slip-arch.c smartrf-sensors.c
  group user
    ./: coord.c hello-world.c project-conf.h sentran.c
  group user/dataformat
    dataformat/: dataformat.c dataformat.h
